# Keil uVision project StarFish_MCU.uvproj, settings and files
target MKL26Z128xxx4 (ARM-ADS)
  device: MKL16Z256xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: StarFish_MCU
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.srec !L
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=.\UV4Build\@L.bin !L
  c flags: Optim=1
  c include: .\Generated_Code;.\Project_Settings\Startup_Code;.\Sources;.\Sources\TSS;.\MQXLITE\include;.\MQXLITE\kernel;.\MQXLITE\psp\cortex_m;.\MQXLITE\psp\cortex_m\compiler\uv4;.\MQXLITE\psp\cortex_m\core\M0;.\common\PDD;.\APP;.\common\shell;.\common\drivers;.\common\drivers\spi;.\common\drivers\W25Q32;.\common\drivers\adc;.\common\drivers\dma;.\common\drivers\lptmr;.\common\drivers\smc;.\common\drivers\eink
  asm misc: --cpreproc
  asm include: .\Generated_Code;.\MQXLITE\include;.\MQXLITE\kernel;.\MQXLITE\psp\cortex_m;.\MQXLITE\psp\cortex_m\compiler\uv4;.\MQXLITE\psp\cortex_m\core\M0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  link misc: --entry=__boot
  group Generated_Code
    ./Generated_Code/: Cpu.c I2C.c MQX1.c PE_LDD.c SystemTimer1.c Vectors.c task_template_list.c PWMTimerRGB.c
  group Project_Settings_Startup_Code
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
  group Sources
    ./Sources/: Events.c MMA845xQ.c ProcessorExpert.c mqx_tasks.c
  group MQXLITE_include
    ./MQXLITE/include/: queue.h klog.h log.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwsem_prv.h lwtimer.h lwtimer_prv.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_macros.h mqx_str.h mqxlite.h mqxlite_cnfg.h mqxlite_prv.h mutex.h mutex_prv.h
  group MQXLITE_kernel
    ./MQXLITE/kernel/: time_ticks.c idletask.c int.c klog.c lwevent.c lwlog.c lwmsgq.c lwsem.c lwtimer.c mqx_utils.c mqxlite.c mutex.c qu_test.c sched.c task.c
  group MQXLITE_psp_cortexm
    ./MQXLITE/psp/cortex_m/: stack_st.c cortex.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c mem_zero.c psp_iinit.c psp_supp.c psp_tiad.c psp_tinm.c psp_tisu.c sc_irdyq.c stack_bu.c stack_de.c
  group MQXLITE_psp_cortexm_compiler_uv4
    ./MQXLITE/psp/cortex_m/compiler/uv4/: comp.h asm_mac.h boot.S
  group MQXLITE_psp_cortexm_core_M0
    ./MQXLITE/psp/cortex_m/core/M0/: psp_prv.inc dispatch.S
  group Driver
    ./common/drivers/: nvic.c uart.c
    ./common/drivers/spi/: MKL_spi.c
    ./common/drivers/W25Q32/: w25x32.c
    ./common/drivers/adc/: adc.c
    ./common/drivers/dma/: DMA1.c
    ./common/drivers/lptmr/: lptmr.c
    ./common/drivers/smc/: smc.c
    ./common/drivers/eink/: eink_display.h Eink.lib
  group APP
    ./APP/: app_shell.c app_trace.c app_mma8451.c acos.c app_wifi.c partition.h app_flashwrite.c
  group Shell
    ./common/shell/: shell.c
